# IAR project FlashLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: .; framework2; ..\..\..\..\..\..\..\..\..\component\soc\realtek\common\bsp; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\..\..\..\..\..\..\component\common\api\network\include; ..\..\..\..\..\..\..\..\..\component\common\api; ..\..\..\..\..\..\..\..\..\component\common\api\platform; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\..\..\..\..\..\..\component\common\utilities; ..\..\..\..\..\..\..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashLoader.bin
  ILINK.IlinkOutputFile: FlashRTL8195aMP.out
  ILINK.IlinkIcfFile: mx25l8008_flashloader_mp.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: flash_MX25L8008.c
  group Framework
    framework2/: flash_loader.c flash_loader_asm.s
  group rtl8195a
    rtl8195a/: hal_misc.c hal_spi_flash_ram.c
